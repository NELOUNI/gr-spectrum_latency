<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>MSOD_SSLSensor_N210</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ActualBW</value></param>
<param><key>value</key><value>channel_bw * num_ch</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Vsq2W_dB</value></param>
<param><key>value</key><value>-10.0 * math.log10(fft_size * int(window_power) * impedance)</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>value</key><value>10.08e6</value></param>
<param><key>label0</key><value>10.08e6</value></param>
<param><key>label1</key><value>9e6</value></param>
<param><key>label2</key><value>4.5e6</value></param>
<param><key>label3</key><value>2.7e6</value></param>
<param><key>label4</key><value>1.08e6</value></param>
<param><key>label</key><value>bandwidth</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>10.08e6</value></param>
<param><key>option1</key><value>9e6</value></param>
<param><key>option2</key><value>4.5e6</value></param>
<param><key>option3</key><value>2.7e6</value></param>
<param><key>option4</key><value>1.08e6</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>724e6</value></param>
<param><key>label0</key><value>AT&amp;T</value></param>
<param><key>label1</key><value>Verizon</value></param>
<param><key>label2</key><value>ChannelEmulator</value></param>
<param><key>label</key><value>center_freq</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>709.01e6</value></param>
<param><key>option1</key><value>782e6</value></param>
<param><key>option2</key><value>724e6</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_bw</value></param>
<param><key>value</key><value>hz_per_bin * round(bandwidth / num_ch / hz_per_bin)</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>dest_host</value></param>
<param><key>value</key><value>"129.6.142.103"</value></param>
<param><key>label0</key><value>pwct1</value></param>
<param><key>label1</key><value>NEO_VM</value></param>
<param><key>label2</key><value>pwct5Desktop</value></param>
<param><key>label3</key><value>Pwct5</value></param>
<param><key>label</key><value>dest_host</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>"pwct1.ctl.nist.gov"</value></param>
<param><key>option1</key><value>"129.6.142.103"</value></param>
<param><key>option2</key><value>"129.6.142.181"</value></param>
<param><key>option3</key><value>"pwct5.ctl.nist.gov"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>625</value></param>
<param><key>label0</key><value>625</value></param>
<param><key>label1</key><value>1024</value></param>
<param><key>label2</key><value>512</value></param>
<param><key>label3</key><value>256</value></param>
<param><key>label4</key><value>128</value></param>
<param><key>label</key><value>fft_size</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>625</value></param>
<param><key>option1</key><value>1024</value></param>
<param><key>option2</key><value>512</value></param>
<param><key>option3</key><value>256</value></param>
<param><key>option4</key><value>128</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hz_per_bin</value></param>
<param><key>value</key><value>samp_rate / fft_size</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>impedance</value></param>
<param><key>value</key><value>50.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>meas_interval</value></param>
<param><key>value</key><value>1e-3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>meas_period</value></param>
<param><key>value</key><value>max(1, int(round(meas_interval * samp_rate / fft_size)))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mywindow</value></param>
<param><key>value</key><value>window.blackmanharris(fft_size)</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>num_ch</value></param>
<param><key>value</key><value>56</value></param>
<param><key>label0</key><value>56</value></param>
<param><key>label1</key><value>50</value></param>
<param><key>label2</key><value>25</value></param>
<param><key>label3</key><value>15</value></param>
<param><key>label4</key><value>8</value></param>
<param><key>label</key><value>num_ch</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>56</value></param>
<param><key>option1</key><value>50</value></param>
<param><key>option2</key><value>25</value></param>
<param><key>option3</key><value>15</value></param>
<param><key>option4</key><value>8</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>rx_gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>31.5</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>12.5e6</value></param>
<param><key>label0</key><value>12.5e6</value></param>
<param><key>label1</key><value>15.36e6</value></param>
<param><key>label2</key><value>7.68e6</value></param>
<param><key>label3</key><value>3.84e6</value></param>
<param><key>label4</key><value>1.92e6</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>12.5e6</value></param>
<param><key>option1</key><value>15.36e6</value></param>
<param><key>option2</key><value>7.68e6</value></param>
<param><key>option3</key><value>3.84e6</value></param>
<param><key>option4</key><value>1.92e6</value></param>
<param><key>type</key><value>real</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>variable_uhd_device3_0</value></param>
<param><key>dev_addr</key><value>type=x300, addr=usrp02</value></param>
<param><key>dev_args</key><value>""</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_power</value></param>
<param><key>value</key><value>sum(map(lambda x: x*x, mywindow))</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1.0</value></param>
<param><key>vlen</key><value>num_ch</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>vlen</key><value>num_ch</value></param>
<param><key>k</key><value>30.0 + Vsq2W_dB</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>mywindow</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>spectrum_latency_bin_aggregator</key>
<param><key>id</key><value>spectrum_latency_bin_aggregator_0</value></param>
<param><key>bandwidth</key><value>ActualBW</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>channel_bw</key><value>channel_bw</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>input_vlen</key><value>fft_size</value></param>
<param><key>output_vlen</key><value>num_ch</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>output_bin_index</key><value>[0] * fft_size</value></param>
</block>
<block>
<key>spectrum_latency_bin_statistics</key>
<param><key>id</key><value>spectrum_latency_bin_statistics_0</value></param>
<param><key>meas_period</key><value>meas_period</value></param>
<param><key>vlen</key><value>num_ch</value></param>
</block>
<block>
<key>spectrum_latency_jsonfile_sink</key>
<param><key>id</key><value>spectrum_latency_jsonfile_sink_0</value></param>
<param><key>atten</key><value>0</value></param>
<param><key>avoid_LO</key><value>False</value></param>
<param><key>bandwidth</key><value>bandwidth</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>filename</key><value>"/home/nae/Spectrum-Sensors/N210/Capture.N210/10-25-2016"</value></param>
<param><key>meas_duration</key><value>meas_interval</value></param>
<param><key>num_ch</key><value>num_ch</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sensor_id</key><value>"F37258"</value></param>
<param><key>sensor_key</key><value>"12345"</value></param>
<param><key>sensorLoc</key><value>"/raid/nae/gnuradio/src/gr-spectrum_latency/examples/utils/sensor.loc"</value></param>
<param><key>sensorSys</key><value>"/raid/nae/gnuradio/src/gr-spectrum_latency/examples/utils/sensor.sys"</value></param>
</block>
<block>
<key>spectrum_latency_sslsocket_sink</key>
<param><key>id</key><value>spectrum_latency_sslsocket_sink_0</value></param>
<param><key>atten</key><value>0</value></param>
<param><key>bandwidth</key><value>bandwidth</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>dest_host</key><value>dest_host</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>meas_duration</key><value>meas_interval</value></param>
<param><key>num_ch</key><value>num_ch</value></param>
<param><key>sensor_id</key><value>"F37258"</value></param>
<param><key>sensor_key</key><value>"12345"</value></param>
<param><key>sensorLoc</key><value>"/raid/nae/pybombs/src/gr-spectrum_latency/examples/sensor.loc"</value></param>
<param><key>sensorSys</key><value>"/raid/nae/pybombs/src/gr-spectrum_latency/examples/sensor.sys"</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_radio</key>
<param><key>id</key><value>uhd_rfnoc_streamer_radio_0</value></param>
<param><key>ant</key><value>"RX2"</value></param>
<param><key>freq</key><value>center_freq</value></param>
<param><key>dcenable</key><value>True</value></param>
<param><key>otw_format</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>gain</key><value>rx_gain</value></param>
<param><key>cpu_format</key><value>fc32</value></param>
<param><key>direction</key><value>rx</value></param>
<param><key>num_channels</key><value>1</value></param>
<param><key>radio_index</key><value>1</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>stream_args</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=usrp1</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>InAggr</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>InAggr</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>spectrum_latency_jsonfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>spectrum_latency_sslsocket_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectrum_latency_bin_aggregator_0</source_block_id><sink_block_id>spectrum_latency_bin_statistics_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectrum_latency_bin_statistics_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_radio_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>spectrum_latency_bin_aggregator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
